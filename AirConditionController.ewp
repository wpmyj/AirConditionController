# IAR project AirConditionController.ewp, settings and files
configuration Normal (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: LOCAL_STORAGE_BTL; CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3_EM3585; PHY_EM3XX; APPLICATION_TOKEN_HEADER="app/framework/util/tokens.h"; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/AirConditionController/AirConditionController_endpoint_config.h"; BOARD_HEADER="app\builder\AirConditionController\AirConditionController_board.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="app/builder/AirConditionController/AirConditionController_tokens.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="app/builder/AirConditionController/AirConditionController.h"; __SOURCEFILE__="$FILE_FNAME$"; EMBER_AF_API_EMBER_TYPES="stack/include/ember-types.h"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; ..\..\..; ..\..\..\app\framework\include; ..\..\..\app\util; ..\..\..\stack; ..\..\..\hal; ..\..\..\hal\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: LOCAL_STORAGE_BTL; CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3_EM3585; PHY_EM3XX; APPLICATION_TOKEN_HEADER="app/framework/util/tokens.h"; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/AirConditionController/AirConditionController_endpoint_config.h"; BOARD_HEADER="app\builder\AirConditionController\AirConditionController_board.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="app/builder/AirConditionController/AirConditionController_tokens.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="app/builder/AirConditionController/AirConditionController.h"; EMBER_AF_API_EMBER_TYPES="stack/include/ember-types.h"
  AARM.AUserIncludes: $FILE_DIR$; $PROJ_DIR$; ..\..\..; ..\..\..\app\framework\include; ..\..\..\stack; ..\..\..\app\util; ..\..\..\hal; ..\..\..\hal\..
  OBJCOPY.OOCOutputFile: AirConditionController.s37
  postbuild: AirConditionController.bat $TARGET_BPATH$ \..\..\..
  ILINK.IlinkOutputFile: AirConditionController.out
  ILINK.IlinkConfigDefines: LOCAL_STORAGE_BTL=1
  ILINK.IlinkIcfFile: ..\..\..\hal\micro\cortexm3\em35x\em3585\iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    ../../../app/builder/AirConditionController/: AirConditionController_callbacks.c
    ../../../hal/micro/cortexm3/: bootloader-interface-app.c bootloader-interface.c button-interface.c led-blink.c adc.c assert-crash-handlers.c button.c buzzer.c cstartup-common.c diagnostic.c faults.s79 isr-stubs.s79 led.c mfg-token.c micro-common.c micro.c mpu.c sleep.c token-def.c token.c uart.c ext-device.c spi-master.c
    ../../../app/framework/plugin/address-table/: address-table.c address-table-cli.c
    ../../../app/framework/plugin/counters/: counters-cli.c counters-ota.c counters-soc.c
    ../../../app/framework/plugin/eeprom/: eeprom.c eeprom-cli.c
    ../../../app/util/serial/: ember-printf.c command-interpreter2.c serial.c
    ../../../app/framework/plugin/form-and-join/: form-and-join-afv2.c
    ../../../app/util/common/: form-and-join.c form-and-join-node-adapter.c library.c
    ../../../app/framework/plugin/identify/: identify.c identify-cli.c
    ../../../app/framework/plugin/network-find/: network-find.c
    ../../../app/framework/plugin/ota-bootload/: ota-bootload-cli.c ota-bootload-soc.c
    ../../../app/framework/plugin/ota-client/: ota-client.c ota-client-signature-verify.c ota-client-page-request.c ota-client-cli.c
    ../../../app/framework/plugin/ota-client-policy/: ota-client-policy.c
    ../../../app/framework/plugin/ota-common/: ota-common.c
    ../../../app/framework/plugin/ota-storage-common/: ota-storage-common.c ota-storage-common-cli.c
    ../../../app/framework/plugin/ota-storage-simple/: ota-storage-simple.c ota-storage-simple-simulation.c
    ../../../app/framework/plugin/ota-storage-simple-eeprom/: ota-storage-eeprom.c ota-storage-eeprom-page-erase.c ota-storage-eeprom-read-modify-write.c
    ../../../app/framework/plugin/reporting/: reporting.c reporting-cli.c
    ../../../app/framework/plugin/scan-dispatch/: scan-dispatch.c
    ../../../app/framework/plugin/scenes/: scenes.c scenes-cli.c
    ../../../app/framework/plugin/simple-main/: simple-main.c
    ../../../hal/micro/generic/: antenna-stub.c sim-eeprom.c crc.c endian.c mem-util.c random.c
    ./: call-command-handler.c callback-stub.c stack-handler-stub.c cli.c
    ../../../app/framework/util/: af-event.c af-main-common.c af-main-soc.c attribute-size.c attribute-storage.c attribute-table.c client-api.c print.c print-formatter.c process-cluster-message.c process-global-message.c service-discovery-common.c service-discovery-soc.c message.c multi-network.c time-util.c util.c
    ../../../app/framework/security/: af-node.c af-security-common.c af-trust-center.c crypto-state.c
    ../../../hal/: ember-configuration.c
    ../../../build/hal-library-cortexm3-iar-em3585-em3xx/: hal-library.a
    ../../../app/framework/cli/: core-cli.c network-cli.c option-cli.c plugin-cli.c security-cli.c zcl-cli.c zdo-cli.c
    ../../../app/util/security/: security-address-cache.c
    ../../../hal/micro/cortexm3/usb/: em_usbd.c em_usbtimer.c em_usbdch9.c em_usbdep.c em_usbhal.c em_usbint.c
    ../../../hal/micro/cortexm3/usb/cdc/: callbacks.c descriptors.c
    ../../../app/util/zigbee-framework/: zigbee-device-common.c zigbee-device-library.c
  group Libraries
    ../../../build/alarm-stub-library-cortexm3-iar-em3585-em3xx/: alarm-stub-library.a
    ../../../build/binding-table-library-cortexm3-iar-em3585-em3xx/: binding-table-library.a
    ../../../build/cbke-163k1-stub-library-cortexm3-iar-em3585-em3xx/: cbke-163k1-stub-library.a
    ../../../build/cbke-283k1-stub-library-cortexm3-iar-em3585-em3xx/: cbke-283k1-stub-library.a
    ../../../build/cbke-stub-library-cortexm3-iar-em3585-em3xx/: cbke-stub-library.a
    ../../../build/cbke-library-dsa-sign-stub-cortexm3-iar-em3585-em3xx/: cbke-library-dsa-sign-stub.a
    ../../../build/cbke-library-dsa-verify-stub-cortexm3-iar-em3585-em3xx/: cbke-library-dsa-verify-stub.a
    ../../../build/cbke-library-dsa-verify-283k1-stub-cortexm3-iar-em3585-em3xx/: cbke-library-dsa-verify-283k1-stub.a
    ../../../build/debug-basic-library-cortexm3-iar-em3585-em3xx/: debug-basic-library.a
    ../../../build/debug-extended-stub-library-cortexm3-iar-em3585-em3xx/: debug-extended-stub-library.a
    ../../../build/end-device-bind-stub-library-cortexm3-iar-em3585-em3xx/: end-device-bind-stub-library.a
    ../../../build/enhanced-beacon-request-stub-library-cortexm3-iar-em3585-em3xx/: enhanced-beacon-request-stub-library.a
    ../../../build/gp-stub-library-cortexm3-iar-em3585-em3xx/: gp-stub-library.a
    ../../../build/install-code-library-stub-cortexm3-iar-em3585-em3xx/: install-code-library-stub.a
    ../../../build/multi-network-stub-library-cortexm3-iar-em3585-em3xx/: multi-network-stub-library.a
    ../../../build/packet-validate-library-cortexm3-iar-em3585-em3xx/: packet-validate-library.a
    ../../../build/rf4ce-stack-stub-library-cortexm3-iar-em3585-em3xx/: rf4ce-stack-stub-library.a
    ../../../build/security-library-core-cortexm3-iar-em3585-em3xx/: security-library-core.a
    ../../../build/security-library-link-keys-stub-cortexm3-iar-em3585-em3xx/: security-library-link-keys-stub.a
    ../../../build/zigbee-pro-stack-cortexm3-iar-em3585-em3xx/: zigbee-pro-stack.a
    ../../../build/zll-stub-library-cortexm3-iar-em3585-em3xx/: zll-stub-library.a
    ../../../build/hal-library-cortexm3-iar-em3585-em3xx/: hal-library.a
    ../../../build/sim-eeprom1-library-cortexm3-iar-em3585-em3xx/: sim-eeprom1-library.a
